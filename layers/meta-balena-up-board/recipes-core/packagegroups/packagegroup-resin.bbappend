# add GPU fw required by various Up Board(s)
RDEPENDS:${PN} += "linux-firmware-i915-upboards"
