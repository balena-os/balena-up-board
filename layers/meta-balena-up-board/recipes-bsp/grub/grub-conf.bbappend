MACHINE_SPECIFIC_EXTRA_CMDLINE_up-board = "i915.enable_rc6=0 "