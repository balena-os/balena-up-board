LED_FILE = "/sys/class/leds/upboard\:green\:status/brightness"
