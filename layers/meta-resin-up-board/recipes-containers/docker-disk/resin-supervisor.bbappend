LED_FILE_up-board = "/sys/class/leds/upboard\:green\:/brightness"
