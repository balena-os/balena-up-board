CONNECTIVITY_FIRMWARES_append = " linux-firmware-bcm43430 linux-firmware-iwlwifi-3160"
